<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\CNC_TIMER.ewp</path>
  </project>
  <batchBuild />
</workspace>
